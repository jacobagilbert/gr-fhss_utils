options:
  parameters:
    author: J. Gilbert
    comment: '|-------------------- QT WIDGETS ------------------|'
    copyright: NTESS, LLC
    description: Reference Application
    generate_options: qt_gui
    id: fhss_detector_reference
    output_language: python
    title: Burst Detector Reference
  states: {}

blocks:
- name: decim_taps
  id: variable
  parameters:
    value: firdes.low_pass_2(1, 1, output_cutoff/decimation*2, output_trans_width/decimation*2, output_attenuation)
  states: {}
- name: fir_taps
  id: variable
  parameters:
    value: firdes.low_pass_2(1, 1, 0.5*output_cutoff, 0.5*output_trans_width, output_attenuation)
  states: {}
- name: gain
  id: variable_qtgui_range
  parameters:
    gui_hint: 5,0,1,1
    label: Gain
    start: '0'
    step: '1'
    stop: '70'
    value: '0'
  states: {}
- name: raster_size
  id: variable
  parameters:
    value: '[64,256]'
  states: {}
- name: syncwords
  id: variable
  parameters:
    comment: |-
      UPDATE ME! 
      Change the syncwords to match bursts of interest
    value: '''101010101010101010101010100011, 101010101010101010101010100111'''
  states: {}
- name: tf
  id: variable_qtgui_range
  parameters:
    gui_hint: 4,0,1,1
    label: Throttle Factor
    start: '0'
    step: '1'
    stop: '40'
    value: '20'
  states: {}
- name: analog_fastnoise_source_x_0
  id: analog_fastnoise_source_x
  parameters:
    amp: '.000'
    comment: Optional noise impariment
    noise_type: analog.GR_GAUSSIAN
    samples: '8192'
    seed: '0'
    type: complex
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    type: complex
  states: {}
- name: blocks_file_source_0_0
  id: blocks_file_source
  parameters:
    file: /tmp/data.sigmf-data
    repeat: 'False'
    type: short
  states: {state: disabled}
- name: blocks_file_source_0_0_0
  id: blocks_file_source
  parameters:
    file: /tmp/data.sigmf-data
    repeat: 'False'
    type: complex
  states: {}
- name: blocks_head_0
  id: blocks_head
  parameters:
    num_items: int(samp_rate/2)
    type: complex
  states: {state: bypassed}
- name: blocks_interleaved_short_to_complex_0_1
  id: blocks_interleaved_short_to_complex
  parameters:
    scale_factor: '1.0'
    vector_input: 'False'
  states: {state: disabled}
- name: blocks_message_debug_0_1
  id: blocks_message_debug
  parameters: {}
  states: {state: disabled}
- name: blocks_message_debug_0_1_0
  id: blocks_message_debug
  parameters: {}
  states: {state: disabled}
- name: blocks_multiply_const_vxx_0_1
  id: blocks_multiply_const_vxx
  parameters:
    comment: 'QT Widget: GAIN'
    const: pow(2,(gain/10))
    type: complex
  states: {}
- name: blocks_multiply_const_vxx_0_1_0
  id: blocks_multiply_const_vxx
  parameters:
    const: 'pow(2,-15) '
    type: complex
  states: {state: disabled}
- name: blocks_probe_rate_0
  id: blocks_probe_rate
  parameters:
    alpha: '0.15'
    comment: |-
      Enable the Message Debug ---->
      and disable the throttle block
      for benchmarking performance
    mintime: '500.0'
    type: complex
  states: {}
- name: blocks_skiphead_0
  id: blocks_skiphead
  parameters:
    comment: Skip Head and Head are for running partial files, disable otherwise
    num_items: '1024'
    type: complex
  states: {state: bypassed}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    comment: 'QT Widget: Throttle Factor'
    samples_per_second: samp_rate/10000 * pow(10,tf/10)
    type: complex
  states: {}
- name: burst_width
  id: parameter
  parameters:
    hide: part
    label: Burst Width [Hz]
    short_id: W
    type: intx
    value: int(1e6)
  states: {}
- name: center_freq
  id: parameter
  parameters:
    label: Center Frequency
    short_id: f
    type: eng_float
    value: 915e6
  states: {}
- name: cfe_snr
  id: parameter
  parameters:
    label: CF Est. SNR
    short_id: c
    type: eng_float
    value: '4'
  states: {}
- name: cfo_start_offset
  id: parameter
  parameters:
    label: CFO Start Offset [s]
    type: eng_float
    value: '0'
  states: {}
- name: cfo_threshold
  id: parameter
  parameters:
    label: CFO threshold
    type: eng_float
    value: '0.5'
  states: {}
- name: cfo_time_to_average
  id: parameter
  parameters:
    label: CFO Average Time [s]
    type: eng_float
    value: '0.0005'
  states: {}
- name: decimation
  id: parameter
  parameters:
    label: Decimation
    short_id: d
    type: intx
    value: '32'
  states: {}
- name: fft_size
  id: parameter
  parameters:
    label: FFT Size
    short_id: N
    type: intx
    value: '256'
  states: {}
- name: fhss_utils_cf_estimate_0
  id: fhss_utils_cf_estimate
  parameters:
    channel_freqs: '[]'
    method: fhss_utils.MIDDLE_OUT
    snr_min: cfe_snr
    thresh_min: '-25.0'
  states: {}
- name: fhss_utils_fft_burst_tagger_0
  id: fhss_utils_fft_burst_tagger
  parameters:
    burst_post_len: int(round((float(samp_rate)/fft_size)*post_burst_time))
    burst_pre_len: int(round((float(samp_rate)/fft_size)*pre_burst_time))
    burst_width: burst_width
    center_frequency: center_freq
    debug: 'True'
    fft_size: fft_size
    history_size: int(round((float(samp_rate)/fft_size)*hist_time))
    lookahead: int(round((float(samp_rate)/fft_size)*lookahead_time))
    max_burst_len: '0'
    max_bursts: '0'
    minoutbuf: 1024*1000*0
    sample_rate: samp_rate
    threshold: threshold
  states: {}
- name: fhss_utils_sigmf_meta_writer_0
  id: fhss_utils_sigmf_meta_writer
  parameters:
    comment: |-
      Optional: save SigMF annotations
      to view in a tool like inspectrum
    dtype: cf32_le
    filename: /tmp/data.sigmf-meta
    freq: int(center_freq)
    label: sigmf_label
    rate: int(samp_rate)
  states: {}
- name: fhss_utils_tagged_burst_to_pdu_0
  id: fhss_utils_tagged_burst_to_pdu
  parameters:
    decimation: int(decimation/2)
    max_burst_time: max_burst_time
    min_burst_time: min_burst_time
    relative_center_frequency: '0.0'
    relative_sample_rate: '1.0'
    relative_span: '1.0'
    sample_rate: samp_rate
    taps: decim_taps
    threads: '3'
  states: {}
- name: hist_time
  id: parameter
  parameters:
    hide: part
    label: History Time [s]
    short_id: H
    type: eng_float
    value: '0.0005'
  states: {}
- name: lookahead_time
  id: parameter
  parameters:
    hide: part
    label: Lookahead Time [s]
    short_id: L
    type: eng_float
    value: '0.0005'
  states: {}
- name: max_burst_time
  id: parameter
  parameters:
    hide: part
    label: Max Burst Time [s]
    short_id: M
    type: eng_float
    value: '0.5'
  states: {}
- name: min_burst_time
  id: parameter
  parameters:
    hide: part
    label: Min Burst Time [s]
    short_id: m
    type: eng_float
    value: '0.0002'
  states: {}
- name: note_0
  id: note
  parameters:
    comment: |-
      .                                                                                                                                                                                                                                  Burst Detection
      ---------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------
    note: SECTION
  states: {}
- name: note_0_0
  id: note
  parameters:
    comment: |-
      .                                                                                                                                                                                                                                  Tuning Parameters
      ---------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------
    note: SECTION
  states: {}
- name: note_0_0_0
  id: note
  parameters:
    comment: |-
      .                                                                                                                                                                                                                                  Input
      ---------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------
    note: SECTION
  states: {}
- name: note_0_0_1
  id: note
  parameters:
    alias: '-'
    comment: .                                   |----------------------------------------------------------------------------------- COMMON CONFIGURATION PARAMETERS  ---------------------------------------------------------------------------------------------------------|                      |------------ ADVANCED CONFIGURATION PARAMETERS  -------------|
  states: {}
- name: note_0_1
  id: note
  parameters:
    comment: |-
      .                                                                                                                                                                                                                                  FM Demod and Symbol Recovery
      ---------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------
    note: SECTION
  states: {}
- name: note_0_1_0
  id: note
  parameters:
    comment: |-
      .                                                                                                                                                                                                                                  Align and Raster Select Bursts				
      ---------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------
    note: SECTION
  states: {}
- name: note_1
  id: note
  parameters:
    comment: |-
      The blocks here are also
      available  wrapped up in
      a python hier block
    note: README
  states: {}
- name: note_1_0
  id: note
  parameters:
    comment: |-
      The Fine Time Measurement block can truncate the start of bursts which 
      may not be desirable, so it is disabled for the purposes of this reference.
    note: README
  states: {}
- name: note_2
  id: note
  parameters:
    comment: |-
      Enable the CSV writer to save the data in the bursts to file. To open the bits in
      URH, remove the comma separations and ensure the file extetnsion is *.txt:
                  sed 's/,//g' burst_bits.csv > bits.txt
  states: {}
- name: note_2_0
  id: note
  parameters:
    note: ====> DEFRAMER
  states: {}
- name: output_attenuation
  id: parameter
  parameters:
    hide: part
    label: Output Attenuation
    type: eng_float
    value: '40'
  states: {}
- name: output_cutoff
  id: parameter
  parameters:
    hide: part
    label: Output Cutoff [cycles/samp]
    type: eng_float
    value: '0.5'
  states: {}
- name: output_trans_width
  id: parameter
  parameters:
    hide: part
    label: Output Trans. Width [cycles/samp]
    type: eng_float
    value: '0.05'
  states: {}
- name: pdu_utils_pack_unpack_0
  id: pdu_utils_pack_unpack
  parameters:
    bit_order: pdu_utils.BIT_ORDER_MSB_FIRST
    mode: pdu_utils.MODE_PACK_BYTE
  states: {}
- name: pdu_utils_pdu_align_0
  id: pdu_utils_pdu_align
  parameters:
    offset: '-24'
    syncwords: syncwords
    threshold: '0'
  states: {}
- name: pdu_utils_pdu_clock_recovery_0
  id: pdu_utils_pdu_clock_recovery
  parameters:
    binary_slice: none
    debug: 'False'
    win_type: pdu_utils.TUKEY_WIN
  states: {}
- name: pdu_utils_pdu_clock_recovery_0_0
  id: pdu_utils_pdu_clock_recovery
  parameters:
    binary_slice: binary
    debug: 'False'
    win_type: pdu_utils.TUKEY_WIN
  states: {}
- name: pdu_utils_pdu_fine_time_measure_0
  id: pdu_utils_pdu_fine_time_measure
  parameters:
    average_width: '10'
    buffer_percent: '15'
    post_burst_time: post_burst_time
    pre_burst_time: pre_burst_time*10
  states: {state: disabled}
- name: pdu_utils_pdu_fir_filter_1
  id: pdu_utils_pdu_fir_filter
  parameters:
    decimation: '2'
    taps: fir_taps
  states: {}
- name: pdu_utils_pdu_head_tail_0
  id: pdu_utils_pdu_head_tail
  parameters:
    histsize: raster_size[0]
    length: raster_size[1]
    pdu_type: pdu_utils.INPUTTYPE_UNPACKED_BYTE
  states: {}
- name: pdu_utils_pdu_quadrature_demod_cf_0
  id: pdu_utils_pdu_quadrature_demod_cf
  parameters:
    sensitivity: '1.0'
  states: {}
- name: pdu_utils_pdu_split_0_0
  id: pdu_utils_pdu_split
  parameters:
    comment: |-
      Enable the Message Debug ---->
      to see PDU Metadata printed
    pass_empty: 'False'
  states: {}
- name: post_burst_time
  id: parameter
  parameters:
    hide: part
    label: Post Burst Time [s]
    short_id: P
    type: eng_float
    value: '0.0002'
  states: {}
- name: pre_burst_time
  id: parameter
  parameters:
    hide: part
    label: Pre Burst Time [s]
    short_id: p
    type: eng_float
    value: '0.0002'
  states: {}
- name: pylambda_pdu_lambda_0
  id: pylambda_pdu_lambda
  parameters:
    fn: 'lambda x: np.abs(x)'
    key: pmt.intern("key")
    metadict: Uniform Vector
  states: {}
- name: qtgui_time_raster_sink_x_0
  id: qtgui_time_raster_sink_x
  parameters:
    color1: '2'
    gui_hint: 3,0,1,2
    name: '"Bit Raster"'
    ncols: raster_size[1]
    nrows: raster_size[0]
    samp_rate: '1'
    type: msg_byte
    zmin: '0'
  states: {state: disabled}
- name: qtgui_time_sink_x_0_0_0_0_0
  id: qtgui_time_sink_x
  parameters:
    gui_hint: 4,2,3,1
    label1: ''
    name: '"FM Demodulation"'
    size: '102400'
    srate: samp_rate/decimation
    tr_delay: '.001'
    tr_level: '0.000001'
    type: msg_float
    update_time: '0.01'
    ymax: '2'
    ymin: '-2'
  states: {}
- name: qtgui_time_sink_x_0_0_0_0_0_0
  id: qtgui_time_sink_x
  parameters:
    gui_hint: 2,0,1,3
    label1: ' '
    label2: ' '
    name: '"Burst Tagger Threshold"'
    size: '102400'
    srate: '1'
    style2: '3'
    tr_delay: '.001'
    tr_level: '0.000001'
    type: msg_complex
    update_time: '0.001'
    ymax: '-30'
    ymin: '-100'
  states: {}
- name: qtgui_time_sink_x_0_0_0_0_0_0_0_0
  id: qtgui_time_sink_x
  parameters:
    grid: 'True'
    gui_hint: 4,3,3,1
    label1: ''
    marker1: '0'
    name: '"Soft Symbols"'
    size: '102400'
    srate: '1'
    style1: '0'
    tr_delay: '.001'
    tr_level: '0.000001'
    type: msg_float
    update_time: '0.01'
    ymax: '1.5'
    ymin: '-1.5'
  states: {}
- name: qtgui_time_sink_x_0_0_0_0_0_1
  id: qtgui_time_sink_x
  parameters:
    gui_hint: 2,3,1,1
    label1: ' '
    label2: ' '
    marker2: '0'
    name: '"Bandwidth Estimator"'
    size: '102400'
    srate: samp_rate/decimation*2
    style2: '0'
    tr_delay: '.001'
    tr_level: '0.000001'
    type: msg_complex
    update_time: '0.01'
    ymax: '-40'
    ymin: '-100'
  states: {}
- name: qtgui_time_sink_x_0_0_0_0_0_2
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    gui_hint: 4,1,3,1
    label1: ''
    name: '"AM Demodulation"'
    size: '102400'
    srate: samp_rate/decimation
    tr_delay: '.001'
    tr_level: '0.000001'
    type: msg_float
    update_time: '0.01'
    ymax: '2'
    ymin: '-2'
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate/decimation
    fc: '0'
    fftsize: '128'
    gui_hint: 1,3,1,1
    name: '"Burst Spectrogram"'
    showports: 'True'
    type: msg_complex
    update_time: '0.005'
  states: {}
- name: qtgui_waterfall_sink_x_0_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    gui_hint: 1,0,1,3
    int_max: '0'
    int_min: '-120'
    name: '"Input Spectrogram"'
    showports: 'True'
    type: complex
    update_time: '0.01'
  states: {}
- name: samp_rate
  id: parameter
  parameters:
    label: Sample Rate
    short_id: r
    type: intx
    value: int(40e6)
  states: {}
- name: sandia_utils_csv_writer_0_0
  id: sandia_utils_csv_writer
  parameters:
    add_metadata: 'False'
    data_type: '''uint8'''
    file: /tmp/burst_bits.csv
    metadata_format: '''start_offset(uint64), center_frequency(double), symbol_rate(uint64)'''
    precision: '0'
  states: {state: disabled}
- name: sigmf_label
  id: parameter
  parameters:
    hide: part
    label: SigMF Label
    short_id: l
    type: str
    value: '''radio1'''
  states: {}
- name: threshold
  id: parameter
  parameters:
    label: Threshold
    short_id: t
    type: eng_float
    value: '8'
  states: {}
- name: uhd_usrp_source_1
  id: uhd_usrp_source
  parameters:
    ant0: TX/RX
    center_freq0: center_freq
    clock_rate: '0.0'
    dev_args: '""'
    gain0: gain
    minoutbuf: 2048*1000
    samp_rate: samp_rate
    sync: sync
    type: fc32
  states: {state: disabled}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: input
  states: {}
- name: virtual_sink_0_0
  id: virtual_sink
  parameters:
    stream_id: bursts
  states: {}
- name: virtual_sink_0_0_0
  id: virtual_sink
  parameters:
    stream_id: hard_syms
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: input
  states: {}
- name: virtual_source_0_0
  id: virtual_source
  parameters:
    stream_id: input
  states: {}
- name: virtual_source_0_2
  id: virtual_source
  parameters:
    stream_id: bursts
  states: {}
- name: virtual_source_0_2_0
  id: virtual_source
  parameters:
    stream_id: hard_syms
  states: {}

connections:
- [analog_fastnoise_source_x_0, '0', blocks_add_xx_0, '1']
- [blocks_add_xx_0, '0', blocks_multiply_const_vxx_0_1, '0']
- [blocks_file_source_0_0, '0', blocks_interleaved_short_to_complex_0_1, '0']
- [blocks_file_source_0_0_0, '0', blocks_skiphead_0, '0']
- [blocks_head_0, '0', blocks_throttle_0, '0']
- [blocks_interleaved_short_to_complex_0_1, '0', blocks_multiply_const_vxx_0_1_0, '0']
- [blocks_multiply_const_vxx_0_1, '0', virtual_sink_0, '0']
- [blocks_multiply_const_vxx_0_1_0, '0', blocks_skiphead_0, '0']
- [blocks_probe_rate_0, rate, blocks_message_debug_0_1_0, print]
- [blocks_skiphead_0, '0', blocks_head_0, '0']
- [blocks_throttle_0, '0', blocks_add_xx_0, '0']
- [fhss_utils_cf_estimate_0, debug, qtgui_time_sink_x_0_0_0_0_0_1, in]
- [fhss_utils_cf_estimate_0, out, fhss_utils_sigmf_meta_writer_0, in]
- [fhss_utils_cf_estimate_0, out, pdu_utils_pdu_fir_filter_1, pdu_in]
- [fhss_utils_fft_burst_tagger_0, '0', fhss_utils_tagged_burst_to_pdu_0, '0']
- [fhss_utils_fft_burst_tagger_0, debug, qtgui_time_sink_x_0_0_0_0_0_0, in]
- [fhss_utils_tagged_burst_to_pdu_0, cpdus, fhss_utils_cf_estimate_0, in]
- [pdu_utils_pdu_align_0, pdu_out, pdu_utils_pack_unpack_0, pdu_in]
- [pdu_utils_pdu_align_0, pdu_out, pdu_utils_pdu_head_tail_0, pdu_in]
- [pdu_utils_pdu_align_0, pdu_out, sandia_utils_csv_writer_0_0, in]
- [pdu_utils_pdu_clock_recovery_0, pdu_out, pdu_utils_pdu_split_0_0, pdu_in]
- [pdu_utils_pdu_clock_recovery_0, pdu_out, qtgui_time_sink_x_0_0_0_0_0_0_0_0, in]
- [pdu_utils_pdu_clock_recovery_0_0, pdu_out, virtual_sink_0_0_0, '0']
- [pdu_utils_pdu_fine_time_measure_0, pdu_out, virtual_sink_0_0, '0']
- [pdu_utils_pdu_fir_filter_1, pdu_out, pdu_utils_pdu_fine_time_measure_0, pdu_in]
- [pdu_utils_pdu_fir_filter_1, pdu_out, virtual_sink_0_0, '0']
- [pdu_utils_pdu_head_tail_0, head, qtgui_time_raster_sink_x_0, in]
- [pdu_utils_pdu_quadrature_demod_cf_0, fpdus, pdu_utils_pdu_clock_recovery_0, pdu_in]
- [pdu_utils_pdu_quadrature_demod_cf_0, fpdus, pdu_utils_pdu_clock_recovery_0_0, pdu_in]
- [pdu_utils_pdu_quadrature_demod_cf_0, fpdus, qtgui_time_sink_x_0_0_0_0_0, in]
- [pdu_utils_pdu_split_0_0, dict, blocks_message_debug_0_1, print]
- [pylambda_pdu_lambda_0, pdu, qtgui_time_sink_x_0_0_0_0_0_2, in]
- [uhd_usrp_source_1, '0', virtual_sink_0, '0']
- [virtual_source_0, '0', fhss_utils_fft_burst_tagger_0, '0']
- [virtual_source_0_0, '0', blocks_probe_rate_0, '0']
- [virtual_source_0_0, '0', qtgui_waterfall_sink_x_0_0, '0']
- [virtual_source_0_2, '0', pdu_utils_pdu_quadrature_demod_cf_0, cpdus]
- [virtual_source_0_2, '0', pylambda_pdu_lambda_0, pdu]
- [virtual_source_0_2, '0', qtgui_waterfall_sink_x_0, in]
- [virtual_source_0_2_0, '0', pdu_utils_pdu_align_0, pdu_in]

metadata:
  file_format: 1
